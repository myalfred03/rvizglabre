Commit message: add Math robot airplane

File: modelos/Math/Cubo.urdf (robot description, URDF)
Before this commit: robot example, 3 links, 2 joints
Links:
- link link_1: geometry visual mesh filename=package://rvizglabre/modelos/Math/stl/jet1.stl
