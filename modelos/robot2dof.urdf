Commit message: change  day 1 internship

File: modelos/robot2dof.urdf (robot description, URDF)
Before this commit: robot origins, 4 links, 3 joints
Joints:
- joint joint_1: axis 1 0 0 -> 0 0 1
